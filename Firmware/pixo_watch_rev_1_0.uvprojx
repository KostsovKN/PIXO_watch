# Keil uVision project pixo_watch_rev_1_0.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L452CEUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pixo_watch_rev_1_0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: stm32l452xx.h clock.c clock.h gpio.c gpio.h systick.c systick.h Timer.c Timer.h spi1.c spi1.h uart1.c uart1.h frames.c frames.h ledmatrix.c ledmatrix.h i2c.c i2c.h main.c mpu9250.c MPU9250.h rtc.c rtc.h
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:Startup 1.3.1
